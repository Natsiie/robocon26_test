Commit message: 调整雷达外参;调整方向控制模式相关参数

File: src/rm_related_pkgs/robot_description_pkg/urdf/robot.urdf (robot description, URDF)
Before this commit: robot simple_robot, 6 links, 5 joints
Joints:
- joint yaw_to_lidar_joint: origin xyz=0 0.06 0.2 rpy=0 0 0 -> xyz=0 0.06 0.2 rpy=3.1415926 0 1.57079
